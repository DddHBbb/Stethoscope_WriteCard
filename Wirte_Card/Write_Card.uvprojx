# Keil uVision project Write_Card.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Write_Card +hex
  AfterMake: D:\Deuce\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\FakeC\Tingzhen_Version\Tingzhen_Program\Stethoscope.bin D:\FakeC\Tingzhen_Version\Tingzhen_Program\Objects\Stethoscope.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_USB_OTG_FS
  c include: .\CORE;.\FATFS\exfuns;.\FATFS\src\option;.\MALLOC;.\SYSTEM;.\TEXT;.\FATFS\src;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\HARDWARE\WM8978;.\HARDWARE\W25QXX;.\HARDWARE\SPI;.\HARDWARE\SDIO;.\HARDWARE\SAI;.\HARDWARE;.\HARDWARE\IIC;.\USB\STM32_USB_Device_Library\Class\msc\inc;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_OTG_Driver\inc;.\USB\USB_APP;.\HARDWARE\OLED;.\NFC\Inc;.\NFC\rfal\Inc;.\NFC\ST25R95;.\NFC_WR\common\inc;.\NFC_WR\CR95HF;.\NFC_WR\Inc;.\NFC_WR\lib_pcd\inc;.\NFC_WR\mcc_src;.\NFC_WR\CR95HF;.\HARDWARE\IWDG;.\HARDWARE\KEY;.\HARDWARE\delay;.\HARDWARE\LOW_PWR;.\TASK;.\HARDWARE\RTC;.\HARDWARE\OLED;.\HARDWARE;.\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
    ./SYSTEM/: system_stm32f4xx.c sys.c
    ./CORE/: startup_stm32f429xx.s
  group TASK
    ./TASK/: Task.c SoftTimer.c
    ./HARDWARE/: GPIOConfig.c
  group HardWare
    ./HARDWARE/WM8978/: wm8978.c
    ./HARDWARE/W25QXX/: w25qxx.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/SAI/: sai.c
    ./HARDWARE/SDIO/: sdio_sdcard.c
    ./HARDWARE/: usart.c wavplay.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/IWDG/: iwdg.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/delay/: D_delay.c
    ./HARDWARE/LOW_PWR/: low_pwr.c
    ./HARDWARE/RTC/: rtc.c
  group FONT
    ./TEXT/: fontupd.c text.c
  group FATFS
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ./FATFS/src/: ff.c diskio.c
  group HAL_Drivers
    ./HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group USB_OTG
    ./USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ./USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_req.c usbd_ioreq.c
    ./USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_scsi.c usbd_msc_data.c
  group USB_Config
    ./USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group NFC
    ./NFC/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_rfst25r95.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
    ./NFC/Src/: demo.c demo_ce.c logger.c
    ./NFC/ST25R95/: st25r95.c st25r95_com.c st25r95_com_spi.c st25r95_com_uart.c timer.c
  group NFC_WR
    ./NFC_WR/common/src/: lib_95HFConfigManager.c
    ./NFC_WR/CR95HF/: drv_95hf.c
    ./NFC_WR/lib_pcd/src/: lib_iso14443Apcd.c lib_nfctype2pcd.c lib_pcd.c
    ./NFC_WR/mcc_src/: mcc.c mcc_crypto.c mcc_crypto_card.c mcc_crypto_reader.c mcc_macros.c mcc_raw_request.c
    ./NFC_WR/: stm32f4xx_hal_msp.c stm32f4xx_it.c
software components: RTOS:kernel 3.1.3, RTOS:shell 3.1.3
